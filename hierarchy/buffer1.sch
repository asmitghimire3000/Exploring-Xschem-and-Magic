** sch_path: hierarchy/buffer1.sch
**.subckt buffer1 A Y VP VN
*.ipin A
*.opin Y
*.iopin VP
*.iopin VN
X1 A net1 VP VN inverter1
X2 net1 Y VP VN inverter1
**.ends
.end
